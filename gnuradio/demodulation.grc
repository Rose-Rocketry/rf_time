options:
  parameters:
    author: ziemereg
    description: Flowgraph & Python code for demodulating the yagi angle signal.
    generate_options: qt_gui
    id: demodulator
    output_language: python
    title: psk_demodulation
  states: {}

blocks:
- name: bpsk_const
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: test_out
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters:
    comment: Convert unsigned char to float for processing
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: set object reference
    constellation: bpsk_const
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: Change signal bandwidth [int]k depending on bandwidth of modulated signal.
    order: '2'
    w: '12000'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: fcdproplus_fcdproplus_0
  id: fcdproplus_fcdproplus
  parameters:
    devicename: fncb
    freq: '426000000'
    if_gain: '10'
    lnaswitch: '1'
    mixergainswitch: '1'
    ppm: '0'
    unit: '1000'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Recieve Constellation Plot"'
    size: '2'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '2'
    type: complex
  states: {state: disabled}

connections:
- [blocks_uchar_to_float_0, '0', blocks_file_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_uchar_to_float_0, '0']
- [fcdproplus_fcdproplus_0, '0', digital_costas_loop_cc_0, '0']

metadata:
  file_format: 1
